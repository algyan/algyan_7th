# Repository algyan/algyan_7th

File readme.md:

# ALGYAN 7th
  This Repository is "IoT ALGYAN 7th" event novelty board info.
```
  Top  
  |  
  +- board_info : board design information (ex.gerber data, schematics etc.)  
  |  
  +- Howto_Soldering : Instructions for soldering parts  
  |  
  +- HwTestApps :  
  | +- algyan_logo  
  |   +- algyan_logo.h : algyan_logo RGB565(320x240)  
  |   |  
  |   +- algyan_logo.bmp  
  |  
  +- EnvArduinoIDE4ESP32 : 
```

## EAGLE design board_info/algyan-7th.brd

File board_info/readme.md:

[board_design]: img/algyan-7th.png
[board_sch]: img/algyan-7th-sch.png
[esp32_pin_assign]: img/esp32_pin_assign.png
[devkitc_pin_assign]: img/devkitc_pin_assign.png
[pcf8674_pin_assign]: img/pcf8674_pin_assign.png

# Board Info

## <a name="S0">0. Index</a>

* [1. Board Design](#S1)
* [2. Schematics](#S2)
* [3. Pin Assign](#S3)
* [4. Body of Materials](#S4)
  * [4-1. Parts set A(お手軽)](#S4-1)
  * [4-2. Parts set B(手作りFULL)](#S4-2)

---

## <a name="S1">1. Board Design</a>

This board is designed by **Designed by EAGLE 9.6.2**.

* File(brd) : **algyan-7th.brd**
* File(gerber) : **algyan-7th_2022-04-07.zip**
* Image(png) : **img/algyan-7th.png**
    ![Board][board_design]

[↑ Back to Index](#S0)

---

## <a name="S2">2. Schematics</a>

* File(sch) : **algyan-7th.sch**
* File(pdf) : **algyan-7th.pdf**
* Image(png) : **img/algyan-7th-sch.png**  
    ![Board_sch][board_sch]

[↑ Back to Index](#S0)

---

## <a name="S3">3. Pin Assign</a>

* Image(png) : **img/esp32_pin_assign.png**  
    ![esp32_pin_assign][esp32_pin_assign]

* Image(png) : **img/devkitc_pin_assign.png**  
    ![devkitc_pin_assign][devkitc_pin_assign]

* Image(png) : **img/pcf8674_pin_assign.png**  
    ![pcf8674_pin_assign][pcf8674_pin_assign]

[↑ Back to Index](#S0)

---

## <a name="S4">4. Body of Materials</a>

### <a name="S4-1">4-1. Parts set A(お手軽)</a>

|No.|部品名|型番・値|個数|購入リスト|種類|オンライン販売URL|
|:-:|:---:|:------:|:-:|:--------:|:----|:---------------|
|4|ESP32-DevKitC-32E(4MB)||1|M-15673 1|U4|https://akizukidenshi.com/catalog/g/gM-15673/|
|5|FRAM(2Mbit) MB85RS2MT|MB85RS2MT|2|-|U5、U6|https://www.chip1stop.com/view/dispDetail/DispDetail?partId=FJTU-0057134|
|6|I/Oエキスパンダー PCF8574N|PCF8674N|1|I-13522 1|U7|https://akizukidenshi.com/catalog/g/gI-13522/|
|7|Quad Bus Buffer|TC74VHC125F|1|-|U8|https://www.marutsu.co.jp/pc/i/14698/|
|8|Quad Bus Buffer|TC74VHC126F|1|-|U9|https://www.marutsu.co.jp/pc/i/14699/|
|9|2.2\" ILI9341 SPI TFT LCDディスプレイ240x320 ILI9341 LCDスクリーン|2.2_TFT_LCD|1|-|U10|https://www.amazon.co.jp/dp/B08D7D14X9<br>https://www.amazon.co.jp/dp/B01DXBI3I8|
|10|エレクトレットコンデンサーマイク（ＥＣＭ）|C9767|1|P-01810 1|U11|https://akizukidenshi.com/catalog/g/gP-01810/|
|11|CMOS OV7670 640x480 カメラモジュール|OV7670|1|-|CAM1|https://www.amazon.co.jp/dp/B08B39JGDS|
|12|チップ抵抗(2012)|10kΩ|3|R-11797 3|R8、R9、R11、R12、R13、R14、R15、R16、R17、R18、R19、R20|https://akizukidenshi.com/catalog/g/gR-11797/|
|13|チップ抵抗(2012)|1kΩ|1|R-11796 1|R10、R21|https://akizukidenshi.com/catalog/g/gR-11796/|
|14|チップ抵抗(2012)|100Ω|1|R-11795 1|R22、R23|https://akizukidenshi.com/catalog/g/gR-11795/|
|16|チップコンデンサ(2012)|0.1uF|1|P-14573 1|C8、C9、C10、C11、C13、C14|https://akizukidenshi.com/catalog/g/gP-14573/|
|18|チップタクトSW|TVAF06-A020B|1|P-14888 1|SW|https://akizukidenshi.com/catalog/g/gP-14888/|
|20-1|チップLED(赤色)|OSR50805C1C|1|I-06419 1|LED1|https://akizukidenshi.com/catalog/g/gI-06419/|
|21|L型ピンヘッダ3Pin|PH-1X3RG(2)|1|C-15510 1|CN1|https://akizukidenshi.com/catalog/g/gC-15510/|
|22|3.5mm小型ステレオミニジャック　基板取付用|ST-005-G|1|C-02460 1|CN2|https://akizukidenshi.com/catalog/g/gC-02460/|
|25|Ｇｒｏｖｅコネクタ　Ｌ型　スルーホール|Grove Female Header - DIP-4P-2.0mm-90D|1|C-12634 1|CN5、CN6、CN7|https://akizukidenshi.com/catalog/g/gC-12634/|
|26|ダブルピンソケット　（低メス）　２×１３　（２６Ｐ）|2214S-26SG-36|1|C-03139 1|CAM1用ソケット|https://akizukidenshi.com/catalog/g/gC-03139/|
|27|シングルピンソケット　（低メス）　１×２０　（２０Ｐ）|2212S-20SG-36|1|C-03138 1|U4用ソケット、U10用ソケット|https://akizukidenshi.com/catalog/g/gC-03138/|
|28|ピンヘッダ　１×６　（６Ｐ）|PH-1x6SG/RH|1|C-01669 1|U10用ピンヘッダ(SDカードI/F)|https://akizukidenshi.com/catalog/g/gC-01669/|
|29|プラスチックナット＋連結（６角ジョイント）スペーサー（１０ｍｍ）セット||1|P-01864 1|U10、CAM1取り付け用スペーサ、ナット|https://akizukidenshi.com/catalog/g/gP-01864/|
|30|３ｍｍプラネジ（５ｍｍ）（１００個入）||1|P-10358 1|U10、CAM1取り付け用ネジ|https://akizukidenshi.com/catalog/g/gP-10358/|

[↑ Back to Index](#S0)

---

### <a name="S4-2">4-2. Parts set B(手作りFULL)</a>

|No.|部品名|型番・値|個数|購入リスト|種類|オンライン販売URL|
|:-:|:---:|:------:|:-:|:--------:|:----|:---------------|
|1|ESP32-WROOM-32E(16MB)||1|M-15675 1|U1|https://akizukidenshi.com/catalog/g/gM-15675/|
|2|三端子レギュレータ|NJM2845DL1|1|I-11299 1|U2|https://akizukidenshi.com/catalog/g/gI-11299/|
|3|USBシリアルIC|FT231XS-R|1|I-06713 1|U3|https://akizukidenshi.com/catalog/g/gI-06713/|
|5|FRAM(2Mbit) MB85RS2MT|MB85RS2MT|2|-|U5、U6|https://www.chip1stop.com/view/dispDetail/DispDetail?partId=FJTU-0057134|
|6|I/Oエキスパンダー PCF8574N|PCF8674N|1|I-13522 1|U7|https://akizukidenshi.com/catalog/g/gI-13522/|
|7|Quad Bus Buffer|TC74VHC125F|1|-|U8|https://www.marutsu.co.jp/pc/i/14698/|
|8|Quad Bus Buffer|TC74VHC126F|1|-|U9|https://www.marutsu.co.jp/pc/i/14699/|
|9|2.2" ILI9341 SPI TFT LCDディスプレイ240x320 ILI9341 LCDスクリーン|2.2_TFT_LCD|1|-|U10|https://www.amazon.co.jp/dp/B08D7D14X9<br>https://www.amazon.co.jp/dp/B01DXBI3I8|
|10|エレクトレットコンデンサーマイク（ＥＣＭ）|C9767|1|P-01810 1|U11|https://akizukidenshi.com/catalog/g/gP-01810/|
|11|CMOS OV7670 640x480 カメラモジュール|OV7670|1|-|CAM1|https://www.amazon.co.jp/dp/B08B39JGDS|
|12|チップ抵抗(2012)|10kΩ|4|R-11797 4|R1、R2、R6、R7、R8、R9、R11、R12、R13、R14、R15、R16、R17、R18、R19、R20|https://akizukidenshi.com/catalog/g/gR-11797/|
|13|チップ抵抗(2012)|1kΩ|1|R-11796 1|R3、R4、R5、R10、R21|https://akizukidenshi.com/catalog/g/gR-11796/|
|14|チップ抵抗(2012)|100Ω|1|R-11795 1|R22、R23|https://akizukidenshi.com/catalog/g/gR-11795/|
|15|チップコンデンサ(3216)|22uF|1|P-06038 1|C1、C2|https://akizukidenshi.com/catalog/g/gP-06038/|
|16|チップコンデンサ(2012)|0.1uF|1|P-14573 1|C3、C5、C7、C8、C9、C10、C11、C12、C13、C14|https://akizukidenshi.com/catalog/g/gP-14573/|
|17|チップコンデンサ(1608)|0.01uF|1|P-13387 1|C4、C6|https://akizukidenshi.com/catalog/g/gP-13387/|
|18|チップタクトSW|TVAF06-A020B|1|P-14888 1|SW、EN、BOOT|https://akizukidenshi.com/catalog/g/gP-14888/|
|19|チップトランジスタ|2SC2712|1|I-00761 1|T1、T2|https://akizukidenshi.com/catalog/g/gI-00761/|
|20-1|チップLED(赤色)|OSR50805C1C|1|I-06419 1|PWR、TXD、RXD、LED1|https://akizukidenshi.com/catalog/g/gI-06419/|
|21|L型ピンヘッダ3Pin|PH-1X3RG(2)|1|C-15510 1|CN1|https://akizukidenshi.com/catalog/g/gC-15510/|
|22|3.5mm小型ステレオミニジャック　基板取付用|ST-005-G|1|C-02460 1|CN2|https://akizukidenshi.com/catalog/g/gC-02460/|
|23|USB Type-CコネクタDIP化キット|AE-USB2.0-TYPE-C-5077R|1|K-15426 1|CN3USB|https://akizukidenshi.com/catalog/g/gK-15426/|
|24|microUSBコネクタ|ZX62-B-5PA(33)|1|C-11183 1|CN4USB|https://akizukidenshi.com/catalog/g/gC-11183/|
|25|Ｇｒｏｖｅコネクタ　Ｌ型　スルーホール|Grove Female Header - DIP-4P-2.0mm-90D|1|C-12634 1|CN5、CN6、CN7|https://akizukidenshi.com/catalog/g/gC-12634/|
|26|ダブルピンソケット　（低メス）　２×１３　（２６Ｐ）|2214S-26SG-36|1|C-03139 1|CAM1用ソケット|https://akizukidenshi.com/catalog/g/gC-03139/|
|27|シングルピンソケット　（低メス）　１×２０　（２０Ｐ）|2212S-20SG-36|1|C-03138 1|U10用ソケット|https://akizukidenshi.com/catalog/g/gC-03138/|
|28|ピンヘッダ　１×６　（６Ｐ）|PH-1x6SG/RH|1|C-01669 1|U10用ピンヘッダ(SDカードI/F)|https://akizukidenshi.com/catalog/g/gC-01669/|
|29|プラスチックナット＋連結（６角ジョイント）スペーサー（１０ｍｍ）セット||1|P-01864 1|U10、CAM1取り付け用スペーサ、ナット|https://akizukidenshi.com/catalog/g/gP-01864/|
|30|３ｍｍプラネジ（５ｍｍ）（１００個入）||1|P-10358 1|U10、CAM1取り付け用ネジ|https://akizukidenshi.com/catalog/g/gP-10358/|

[↑ Back to Index](#S0)

---

Parts:
BOOT: TVAF06-A020B
C1, C2: 22uF; C3216
C3, C5, C7, C8, C9, C10, C11, C12, C13, C14: 0.1uF; C2012
C4, C6: 0.01uF; C1608
CAM1: OV7670
CN1: PINHD-1X3/90; 1X03/90
CN2: ST-005-G07; ST-005-G
CN3USB: AE-USB20-TYPE-C-5077R
CN4USB: ZX62-B-5PA(33); HRS_ZX62-B-5PA(33)
CN5, CN6, CN7: 4P-2.0-90D; HW4-2.0-90D
EN: TVAF06-A020B
LED1: LEDCHIPLED_0805; CHIPLED_0805
PWR: LEDCHIPLED_0805; CHIPLED_0805
R1, R2, R6, R7, R8, R9, R11, R12, R17, R18, R19, R20: 10k; R2012
R3, R4, R5, R10, R21: 1k; R2012
R13, R15: 5.1k/(10k); R2012
R14, R16: (10k); R2012
R22, R23: 100; R2012
RXD: LEDCHIPLED_0805; CHIPLED_0805
SJ1, SJ2: SJ2W; SJ_2
SJ3, SJ4, SJ5: SJ
SW: TVAF06-A020B
T1, T2: 2SC2712; SOT23-BEC
TXD: LEDCHIPLED_0805; CHIPLED_0805
U1: ESP-WROOM-32
U2: NJM2845DL1; D-PAK_TO252AA
U3: FT231XS-R; SOP64P599X175-20N
U4: ESP32-DEVKITC-32E; MODULE_ESP32-DEVKITC-32D
U5, U6: MB85RS; DIP8_SOP8
U7: PCF8574N; DIP794W45P254L1969H508Q16
U8: 74HC125D; SO14
U9: 74HC126D; SO14
U10: 2.2_TFT_LCD
U11: C9767

Connections:
+3V3: C2.1, C5.1, C6.1, C8.2, C9.2, C10.2, C11.2, C12.1, C13.2, CAM1.1, CN5.3, CN6.3, CN7.3, PWR.A, R6.2, R7.2, R9.2, R11.2, R12.2, R17.2, R18.2, R19.2, R23.2, RXD.A, SW.2 (S), TXD.A, U1.2 (3V3), U2.3 (OUT), U3.3 (VCCIO), U3.13 (3V3OUT), U3.14 (RESET#), U3.15 (VCC), U4.1 (3V3), U5.8 (VDD), U6.8 (VDD), U7.16 (VCC), U8.14 (VCC), U9.14 (VCC), U10.LED, U10.VCC
+5V: C1.1, C3.1, C4.1, CN1.1, CN1.3, CN3USB.VBUS, CN4USB.1 (VBUS), U2.1 (IN), U4.19 (EXT_5V)
CBUS1: R5.1, U3.17 (CBUS1)
CBUS2: R4.1, U3.10 (CBUS2)
CLK: U1.20 (CLK), U4.38 (CLK)
CMD: U1.19 (CMD), U4.18 (CMD)
D4: CAM1.12, U8.2 (1A)
DTR: R1.1, T2.E, U3.1 (DTR#)
EN: C7.1, CAM1.17, EN.2 (S), R6.1, T1.C, U1.3 (EN), U4.2 (EN), U10.RST
GND: BOOT.1, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C9.1, C10.1, C11.1, C12.2, C13.1, CAM1.2, CAM1.18, CN1.2, CN2.3 (4), CN3USB.GND1, CN3USB.GND2, CN4USB.5 (GND), CN4USB.SH1 (SHIELD), CN4USB.SH2 (SHIELD), CN4USB.SH3 (SHIELD), CN4USB.SH4 (SHIELD), CN4USB.SH5 (SHIELD), CN4USB.SH6 (SHIELD), CN5.4, CN6.4, CN7.4, EN.1, R3.1, R8.1, R10.1, R13.1, R14.1, R15.1, R16.1, R20.1, R22.1, U1.1 (GND), U1.15 (GND), U1.38 (GND), U1.GND, U2.4 (GND), U3.6 (GND1), U3.16 (GND2), U4.14 (GND1), U4.20 (GND3), U4.26 (GND2), U5.4 (VSS), U6.4 (VSS), U7.1 (A0), U7.2 (A1), U7.3 (A2), U7.8 (GND), U8.7 (GND), U9.7 (GND), U10.GND, U11.-
IO0: BOOT.2 (S), R7.1, T2.C, U1.25 (IO0), U4.33 (IO0)
IO2: CAM1.11, U1.24 (IO2), U4.34 (IO2)
IO4: U1.26 (IO4), U4.32 (IO4), U5.1 (CS)
IO5: U1.29 (IO5), U4.29 (IO5), U10.CS
IO12: U1.14 (IO12), U4.13 (IO12), U8.3 (1Y), U9.3 (1Y)
IO13: U1.16 (IO13), U4.15 (IO13), U8.6 (2Y), U9.5 (2A)
IO14: U1.13 (IO14), U4.12 (IO14), U8.8 (3Y), U9.9 (3A)
IO15: U1.23 (IO15), U4.35 (IO15), U8.12 (4A), U9.12 (4A)
IO16: U1.27 (IO16/RXD2), U4.31 (IO16)
IO17: CAM1.9, U1.28 (IO17/TXD2), U4.30 (IO17)
IO18: U1.30 (IO18), U4.28 (IO18), U5.6 (SCK), U6.6 (SCK), U10.SCK
IO19: U1.31 (IO19), U4.27 (IO19), U5.2 (SO), U6.2 (SO), U10.MISO
IO23: U1.37 (IO23), U4.21 (IO23), U5.5 (SI), U6.5 (SI), U10.MOSI
IO25: CN2.2, U1.10 (IO25), U4.9 (IO25)
IO26: LED1.A, SJ3.1, SJ3.2, SJ4.1, SJ5.2, U1.11 (IO26), U4.10 (IO26)
IO27: U1.12 (IO27), U4.11 (IO27), U10.DC
IO32: U1.8 (IO32), U4.7 (IO32), U6.1 (CS)
IO33: C14.1, U1.9 (IO33), U4.8 (IO33)
IO34: CAM1.14, U1.6 (IO34), U4.5 (IO34)
IO35: CAM1.13, U1.7 (IO35), U4.6 (IO35)
unnamed: R1.2, T1.B
unnamed: R2.2, T2.B
unnamed: LED1.C, R10.2
unnamed: C14.2, R21.1, U11.+
unnamed: R9.1, U6.3 (WP)
unnamed: R11.1, U5.3 (WP)
unnamed: R21.2, R22.2, R23.1
unnamed: R19.1, U5.7 (HOLD)
unnamed: R18.1, U6.7 (HOLD)
unnamed: CN6.2, SJ2.2
unnamed: CN6.1, SJ1.2
unnamed: CN3USB.CC1, R13.2, R14.2
unnamed: CN3USB.CC2, R15.2, R16.2
unnamed: CN3USB.D-, CN4USB.2 (D-), U3.12 (USBDM)
unnamed: CN3USB.D+, CN4USB.3 (D+), U3.11 (USBDP)
unnamed: PWR.C, R3.2
unnamed: R5.2, RXD.C
P0: CN7.1, U7.4 (P0)
P1: CN7.2, U7.5 (P1)
P2: U7.6 (P2)
P3: SJ5.1, U7.7 (P3)
P4: R20.2, U7.9 (P4), U8.1 (_1G), U8.4 (_2G), U8.10 (_3G), U8.13 (_4G), U9.1 (1G), U9.4 (2G), U9.10 (3G), U9.13 (4G)
P5: R8.2, SW.1, U7.10 (P5)
P6: SJ1.1, U7.11 (P6)
P7: SJ2.1, U7.12 (P7)
PCLK: CAM1.7, U8.9 (3A)
RTS: R2.1, T1.E, U3.2 (RTS#)
RXD0: U1.34 (RXD0), U3.20 (TXD), U4.24 (RXD0)
SCL: CAM1.3, CN5.1, R17.1, SJ1.3, U1.36 (IO22), U4.22 (IO22), U7.14 (SCL)
SD0: U1.21 (SD0), U4.37 (SD0)
SD1: U1.22 (SD1), U4.36 (SD1)
SD2: U1.17 (SD2), U4.16 (SD2)
SD3: U1.18 (SD3), U4.17 (SD3)
SDA: CAM1.4, CN5.2, R12.1, SJ2.3, U1.33 (IO21), U4.25 (IO21), U7.15 (SDA)
SD_CS: U9.11 (4Y), U10.SD_CS
SD_MISO: U9.2 (1A), U10.SD_MISO
SD_MOSI: U9.6 (2Y), U10.SD_MOSI
SD_SCK: U9.8 (3Y), U10.SD_SCK
SENSOR_VN: CAM1.15, U1.5 (SENSOR_VN), U4.4 (SENSOR_VN)
SENSOR_VP: CAM1.16, U1.4 (SENSOR_VP), U4.3 (SENSOR_VP)
SP_L: CN2.4@1 (3), SJ4.2
TTXD: R4.2, TXD.C
TXD0: U1.35 (TXD0), U3.4 (RXD), U4.23 (TXD0)
VSYNC: CAM1.5, U8.5 (2A)
XCLK: CAM1.8, U8.11 (4Y)

Notes on the sheet:
ESP32-DevKitC module
ESP32-DevKitC module互換回路
USB Type-Cコネクタ
microUSBコネクタ

Board: 2 copper layers, 99.1 x 78.7 mm, 70 parts (6 on the bottom side), 74 nets.

## Code that names these connections

File HwTestApps/HwTestApps.ino:

// Used Libraries
// * Found in library manager:
//   * PCF8574_library: https://github.com/xreef/PCF8574_library
//   * Adafruit_GFX: https://github.com/adafruit/Adafruit-GFX-Library
//   * Adafruit_ILI9341: https://github.com/adafruit/Adafruit_ILI9341
//   * Adafruit_FRAM_SPI: https://github.com/adafruit/Adafruit_FRAM_SPI
//   * SdFat - Adafruit Fork: https://github.com/adafruit/SdFat
//     with modification: #define USE_STANDARD_SPI_LIBRARY 2 in SdFatConfig.h
//   * Adafruit_ImageReader: https://github.com/adafruit/Adafruit_ImageReader
// * manual install 
//   * OV7670-ESP32: https://github.com/kobatan/OV7670-ESP32

// SD expectation: SD or SDHC, with FAT16 or FAT32, /algyan_logo.bmp at root directory

#include <SPI.h>
#include "algyan7th.h"
#include "Algyan_logo/algyan_logo.h"
#include "PCF8574.h"
#include "Adafruit_GFX.h"
#include "Adafruit_ILI9341.h"
#include "Adafruit_FRAM_SPI.h"
#include "OV7670.h"
// #define USE_STANDARD_SPI_LIBRARY 2 in SdFatConfig.h
#include "SdFat.h"
#include "Adafruit_ImageReader.h"

// Library modules
Adafruit_ILI9341 tft( TFT_CS, TFT_DC, TFT_RST );
PCF8574 pcf8574( PCF8574_ADDR );
Adafruit_FRAM_SPI fram1( FRAM1_CS ), fram2( FRAM2_CS );
#define CAM_MODE QVGA
#if CAM_MODE == QVGA
#define CAM_WIDTH 320
#define CAM_HEIGHT 240
#else
#define CAM_WIDTH 176
#define CAM_HEIGHT 144
uint16_t buf[ CAM_WIDTH * CAM_HEIGHT ];
#endif
OV7670 cam;
const camera_config_t cam_conf = {
    .D0 = 36,
    .D1 = 39,
    .D2 = 34,
    .D3 = 35,
    .D4 = 12,
    .D5 = 2,
    .D6 = 16,
    .D7 = 17,
    .XCLK = 15,
    .PCLK = 14,
    .VSYNC = 13,
    .xclk_freq_hz = 10000000,     // XCLK 10MHz
    .ledc_timer   = LEDC_TIMER_0,
    .ledc_channel = LEDC_CHANNEL_0  
};

// Demo settings
enum State {
    INFO,
    WAIT1,
    BLINK,
    WAIT2,
    FRAM,
    WAIT3,
    LCD,
    WAIT4,
    CAM,
    WAIT5,
    SD,
    WAIT6,
    STATE_NUM
};

State show_info   ( State state, unsigned long wait, char *next_scene );
State wait_sw     ( State state, unsigned long wait, char *next_scene );
State blink_led   ( State state, unsigned long wait, char *next_scene );
State rw_fram     ( State state, unsigned long wait, char *next_scene );
State draw_lcd    ( State state, unsigned long wait, char *next_scene );
State capture_cam ( State state, unsigned long wait, char *next_scene );
State draw_from_sd( State state, unsigned long wait, char *next_scene );
typedef struct {
    State (*func)( State state, unsigned long wait, char *next_scene );
    unsigned long wait;
    char *next_scene;
} TableEntry;
#define NA 0
TableEntry table[STATE_NUM] = {
    { show_info,    NA,   NA              }, /* INFO  */
    { wait_sw,      3000, "LED BLINK"     }, /* WAIT1 */
    { blink_led,    3000, NA              }, /* BLINK */
    { wait_sw,      0,   "FRAM R/W"      }, /* WAIT2 */
    { rw_fram,      NA,   NA              }, /* FRAM  */
    { wait_sw,      3000, "LCD DISP LOGO" }, /* WAIT3 */
    { draw_lcd,     NA,   NA              }, /* LCD   */
    { wait_sw,      3000, "CAM TO LCD"    }, /* WAIT4 */
    { capture_cam,  5000, NA              }, /* CAM   */
    { wait_sw,      0,    "SD TO LCD"     }, /* WAIT5 */
    { draw_from_sd, NA,   NA              }, /* SD    */    
    { wait_sw,      3000, "INFO"          }  /* WAIT6 */
};
inline State next( State state )
{
    return static_cast<State>( ( static_cast<int>( state ) + 1 ) % STATE_NUM );
}

bool pcf8574_init;
bool fram1_init;
bool fram2_init;
bool ov7670_init;
unsigned long lastTime;

enum S_DEV { S_CAM, S_SD };
void SelectDevice( int s_dev ) // Due to unknown reasons, S_DEV instead of int leads compile error
{
    if( s_dev == S_CAM ) {
        pinMode( CAM_VSYNC, INPUT );
        pinMode( CAM_PCLK,  INPUT );
        pcf8574.digitalWrite( CAM_OR_SD , LOW ); // SD
        delay(100);
        Serial.println( "OV7670 camera Init..." );
        esp_err_t err = cam.init( &cam_conf, CAM_MODE, RGB565 );    // カメラを初期化
        if( err != ESP_OK ) {
            Serial.println( "cam.init ERROR" );
        } else {
            ov7670_init = true;
        }
        cam.setPCLK( 2, DBLV_CLK_x4 );  // PCLK 設定 : 10MHz / (pre+1) * 4 --> 13.3MHz  
        cam.vflip( false );
    } else { // S_SD
        pinMode( SD_MOSI, INPUT );
        pinMode( SD_SCK,  INPUT );
        pcf8574.digitalWrite( CAM_OR_SD, HIGH ); // SD
        delay(100);
        pinMode( SD_MOSI, OUTPUT );
        pinMode( SD_SCK,  OUTPUT );
    }
}

void setup() {
    Serial.begin( 115200 );
    delay(1000);
    while( !Serial ) { delay(10); }
    Wire.begin();
    pcf8574.pinMode( CAM_OR_SD, OUTPUT );
    pcf8574.pinMode( SW, INPUT );
    Serial.print( "Init pcf8574..." );
    if( pcf8574.begin() ) {
        Serial.println( "OK" );
        pcf8574_init = true;
    } else {
        Serial.println( "KO" );
    }
    tft.begin();
    tft.setRotation( 3 );
    pinMode( LED, OUTPUT );
    if( fram1.begin() ) {
        Serial.println( "Found SPI FRAM1" );
        fram1_init = true;
    } else {
        Serial.println( "No SPI FRAM1 found ... check your connections\r\n" );
    }
    if( fram2.begin() ) {
        Serial.println( "Found SPI FRAM2" );
        fram2_init = true;
    } else {
        Serial.println( "No SPI FRAM2 found ... check your connections\r\n" );
    }
    SelectDevice( S_CAM );
    gpio_set_pull_mode( GPIO_NUM_12, GPIO_PULLDOWN_ONLY );
}

void loop() {
  static State state = INFO;
  state = table[state].func( state, table[state].wait, table[state].next_scene );
}

#define PRINT( arg )   do { tft.print( arg );   Serial.print( arg ); } while(0)
#define PRINTLN( arg ) do { tft.println( arg ); Serial.println( arg ); } while(0)

State show_info   ( State state, unsigned long wait, char *next_scene )
{
    tft.fillScreen( ILI9341_BLACK );
    tft.setCursor( 0, 0 );
    tft.setTextColor( ILI9341_WHITE );  tft.setTextSize( 2 );
    PRINT( "PCF8574: " );
    PRINTLN( pcf8574_init ? "OK" : "NG" );
    PRINT( "FRAM1: " );
    PRINTLN( fram1_init ? "OK" : "NG" );
    PRINT( "FRAM2: " );
    PRINTLN( fram2_init ? "OK" : "NG" );
    PRINT( "OV7670: " );
    PRINTLN( ov7670_init ? "OK" : "NG" );
    return next( state );
}

State wait_sw     ( State state, unsigned long wait, char *next_scene )
{
    static bool show_message;
    unsigned long curTime = millis();
    if ( curTime - lastTime > wait && !show_message ) {
        tft.fillScreen( ILI9341_BLACK );
        tft.setCursor( 0, 0);
        tft.setTextColor( ILI9341_WHITE );  tft.setTextSize(2);
        PRINT( "Push SW to " );
        PRINTLN( next_scene );
        show_message = true;
    }
    if ( show_message && pcf8574.digitalRead(SW) ) {
        state = next( state );
        show_message = false;
        lastTime = curTime;
    }
    delay( 100 );
    return state;
}

State blink_led   ( State state, unsigned long  wait, char *next_scene )
{
    unsigned long curTime = millis();
    digitalWrite( LED, HIGH );
    delay( 500 );
    digitalWrite( LED, LOW );
    delay(500);
    if ( curTime - lastTime > wait ) {
        state = next( state );
        lastTime = curTime;
    }
    return state;
}

State rw_fram     ( State state, unsigned long  wait, char *next_scene )
{
    uint8_t old1 = fram1.read8( 0x0 );
    fram1.writeEnable( true );
    fram1.write8( 0x0, old1 + 1 );
    fram1.writeEnable( false );
    uint8_t new1 = fram1.read8( 0x0 );

    uint8_t old2 = fram2.read8( 0x0 );
    fram2.writeEnable( true );
    fram2.write8( 0x0, old2 + 2 );
    fram2.writeEnable( false );
    uint8_t new2 = fram2.read8( 0x0 );

    PRINT( "The 1st byte of FRAM1: " ); PRINT( old1 ); PRINT( " -> " ); PRINTLN( new1 );
    PRINT( "The 1st byte of FRAM2: " ); PRINT( old2 ); PRINT( " -> " ); PRINTLN( new2 );

    return next( state );
}

State draw_lcd    ( State state, unsigned long  wait, char *next_scene )
{
    tft.drawRGBBitmap( 0, 0, algyan_logo, ALGYAN_WIDTH, ALGYAN_HEIGHT );
    return next( state );
}

State capture_cam ( State state, unsigned long  wait, char *next_scene )
{
    unsigned long curTime = millis();
#if CAM_MODE == QVGA
    uint16_t *buf;
    for( int y = 0; y < CAM_HEIGHT; ++y ) {
        buf = cam.getLine( y + 1 );
        tft.drawRGBBitmap( 0, y, buf, CAM_WIDTH, 1 );
    }
#else
    cam.getFrame( (uint8_t*)buf );
    tft.drawRGBBitmap( 0, 0, buf, CAM_WIDTH, CAM_HEIGHT );
#endif
    if ( curTime - lastTime > wait ) {
        state = next( state );
        lastTime = curTime;
    }
    return state;
}

State draw_from_sd( State state, unsigned long  wait, char *next_scene )
{
    static bool select;
    if( !select ) {
        SelectDevice( S_SD );
        select = true;
    }
    SPIClass spiSD( HSPI );
    SdFat Sd( &spiSD );
    Adafruit_ImageReader reader( Sd );
    if( Sd.begin( SD_CS, SD_SCK_MHZ( 24 ) ) ) {
        reader.drawBMP("/algyan_logo.bmp", tft, 0, 0);
        SelectDevice( S_CAM );
        select = false;
        state = next( state );
    }
    return state;
}

File HwTestApps/algyan7th.h:

#pragma once
#ifndef ALGYAN7TH_H
#define ALGYAN7TH_H

/////////////////////////////
// misc

#define LED  26 /* out */
#define MIC  33 /* analog in  */
#define JACK 25 /* analog out */

/////////////////////////////
// IO EXPANDER: PCF8574

#define PCF8574_ADDR 0x20
#define CAM_OR_SD    P4
#define SW           P5
// I2C
// SDA 21
// SCL 22

/////////////////////////////
// SPI TFT: ILI9341

#define TFT_CS   5   /* out */
#define TFT_DC   27  /* out */
#define TFT_RST  255 /* not used */
// VSPI
// TFT_SCK  18 /* out */
// TFT_MISO 19 /* in  */
// TFT_MOSI 23 /* out */

/////////////////////////////
// SD on ILI9341

#define SD_CS   15 /* out */
// HSPI
#define SD_SCK  14 /* out */
#define SD_MISO 12 /* in  */
#define SD_MOSI 13 /* out */

/////////////////////////////
// CAMERA: OV7670

#define CAM_ADDR 0x21
#define CAM_VSYNC 13 /* in */
// CAM_HREF /* not used */
#define CAM_PCLK  14 /* in */
#define CAM_XCLK  15 /* out */
#define CAM_D0    36 /* in */
#define CAM_D1    39 /* in */
#define CAM_D2    34 /* in */
#define CAM_D3    35 /* in */
#define CAM_D4    12 /* in */
#define CAM_D5    2  /* in */
#define CAM_D6    16 /* in */
#define CAM_D7    17 /* in */
// I2C
// SDA 21
// SCL 22

/////////////////////////////
// FRAM

#define FRAM1_CS 4  /* out */
#define FRAM2_CS 32 /* out */
// VSPI
// FRAM_SCK  18 /* out */
// FRAM_MISO 19 /* in  */
// FRAM_MOSI 23 /* out */

#endif

## Commit log

2022-06-04 refine readme.md
2022-06-04 add board_info
2022-06-11 added Pin Assign Info.
2022-06-11 Added Instructions for soldering parts.
2022-06-11 fixed indexes, and others.
2022-06-24 add FRAM_FileSystem
2022-06-24 modify FRAM_FileSystem
2022-07-17 Add brief hw test app.
2022-07-17 Add README.md.
